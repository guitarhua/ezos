# Keil uVision project ProjectTemplate.uvproj, settings and files
target stm32_fire (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32_fire +hex
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\..;.\applications;.\configures;..\..\components\cpn_fatfs;..\..\components\cpn_tone;..\..\components\cpn_gui\demo;..\..\components\cpn_gui\inc;..\..\components\cpn_gui\config;..\..\components\cpn_gui\driver;..\..\components\cpn_uip\apps;..\..\components\cpn_uip\tcpip;..\..\components\cpn_uip\uip;..\..\components\cpn_uip\chips;..\..\components\cpn_lib;..\..\components;..\..\ezos;..\..\drivers\drv_sdcard;..\..\drivers\drv_spiflash;..\..\drivers;..\..\drivers\libraries\STM32F10x_StdPeriph_Driver\inc;..\..\drivers\libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\drivers\libraries\CMSIS\CM3\CoreSupport
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group configures
    ./configures/: stm32f10x_conf.h ezos_conf.h ffconf.h lcdgui_conf.h uip_conf.h user_types.h
    ./configures/startup/arm/: startup_stm32f10x_hd.s
  group applications
    ./applications/: main.c irq_handler.c app_define.c app_race_led.c app_sem.c app_mail.c app_message.c app_bell.c app_rtc.c app_sd.c app_eeprom.c app_spiflash.c app_fatfs.c app_sd2flash.c app_tone.c app_gui.c app_net.c
  group cpn_fatfs
    ../../components/cpn_fatfs/: ff.c diskio.c integer.h
    ../../components/cpn_fatfs/option/: ccsbcs.c cc936.c cc936_extern.c
  group cpn_tone
    ../../components/cpn_tone/: cpn_tone.c
    ../../components/cpn_tone/data/: tone_test.c
  group cpn_gui_demo
    ../../components/cpn_gui/demo/: GUIDEMO.h GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group cpn_gui_lib
    ../../components/cpn_gui/inc/: BUTTON.h BUTTON_Private.h CALENDAR.h CHECKBOX.h CHECKBOX_Private.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Intern.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h Global.h GRAPH.h GRAPH_Private.h GUI.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GIF_Private.h GUI_HOOK.h GUI_JPEG_Private.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_DCache.h GUIDRV_DCache_Private.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_FlexColor_Private.h GUIDRV_Generic.h GUIDRV_Lin.h GUIDRV_Lin_Opt_8.h GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_24.h GUIDRV_Lin_Opt_32.h GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.h GUIDRV_Template.h GUIDRV_TemplateI.h GUIDRV_TemplateI_Private.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h IMAGE.h IMAGE_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h RADIO.h RADIO_Private.h SCROLLBAR.h SCROLLBAR_Private.h SLIDER.h SLIDER_Private.h SPINBOX.h SPINBOX_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h
    ../../components/cpn_gui/lib/: emWin520d_CM3.lib
  group cpn_gui_drv
    ../../components/cpn_gui/config/: GUI_X.c GUIConf.c LCDConf.c LCDDriver.c
    ../../components/cpn_gui/driver/: lcd_main.c touch_main.c
  group cpn_uip_apps
    ../../components/cpn_uip/apps/: dhcp.c dns.c smtp.c
    ../../components/cpn_uip/apps/demo/: httpd.c httpd-cgi.c httpd-fs.c tcpc.c tcps.c udpc.c udps.c
  group cpn_uip_tcpip
    ../../components/cpn_uip/tcpip/: socket.c tcp_udp.c uip_sys.c uip_lib.c tcpip.h uip_types.h
  group cpn_uip
    ../../components/cpn_uip/uip/: uip.c uip_arp.c
  group cpn_uip_chips
    ../../components/cpn_uip/chips/: tapdev.c enc28j60_uip.c stm32_eth_uip.c
  group cpn_lib
    ../../components/cpn_lib/: memb.c list.c
  group ezos
    ../../ezos/: ezos_kernel.c ezos_ipc.c ezos.h
  group drv_sdcard
    ../../drivers/drv_sdcard/: drv_sdcard.c drv_sdflash.c sd_sdio.c sd_sdspi.c sd_sdspidma.c
  group drv_spiflash
    ../../drivers/drv_spiflash/: drv_spiflash.c sf_mx25l.c sf_universal.c
  group drivers
    ../../drivers/: assert.c drv_adc1.c drv_extint.c drv_flash.c drv_tcsbus.c drv_timer.c
    ../../Drivers/: drv_ctrlport.c drv_eeprom.c drv_i2c.c drv_key.c drv_led.c drv_rtc_time.c drv_spi.c drv_systick.c drv_uart.c drv_watchdog.c
  group libraries
    ../../drivers/libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../../drivers/libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../drivers/libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group documents
    ../../Documents/: STM32产品线划分.txt STM32工程模板分层说明.txt STM32工程模板版本说明.txt
    ../../documents/: doxygen_demo.c doxygen_demo.h doxygen_other.h
target creat_lib (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Libraries_STM32_CMSIS +hex (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F10X_HD
  c include: ..\..;..\..\Applications;..\..\Modules;..\..\Drivers;..\..\OS;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
